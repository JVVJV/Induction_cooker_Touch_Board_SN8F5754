# Keil uVision project Touch5754.uvproj, settings and files
target Target 1 (MCS-51)
  device: SN8F5754 SONiX
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x3FF5) CLOCK(32000000) MODC2 DPC
  output: Touch5754 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\TouchLib;.\Source
  group System
    ./: OPTIONS_SN8F5754.A51 STARTUP.A51 user_app.c uese_display.c user_iic.c iic.h user_isr.h
    ./Source/: main.c sysmode.c user_init.c user_isr.c user_key.c
  group Touch
    ./Source/: sysmode.h captouch_main.h captouch_equ.h
    ./TouchLib/: captouch_lib.LIB captouch_debug_i2c.LIB captouch_debug_uart.LIB captouch_lpsm.LIB
